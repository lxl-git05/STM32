# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware;../Software;../Control;../System;../Tools;../Top
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group System
    ../System/: PWM.c PWM.h Encoder.c Encoder.h DList.c DList.h
  group Hardware
    ../Hardware/: OLED.c OLED.h OLED_Data.c OLED_Data.h Key.c Key.h bsp_at24c02.c bsp_at24c02.h at24c02_manager.c at24c02_manager.h Param_AT24C02.c Param_AT24C02.h Encoder_Key.c Encoder_Key.h
  group Software
    ../Software/: Serial.c Serial.h MyPID.c MyPID.h
  group Tools
    ../Tools/: Timer_Counter.c Timer_Counter.h Key_Check.c Key_Check.h LED_Flash.c LED_Flash.h
  group Control
    ../Control/: Task.c Task.h
  group Top
    ../Top/: Mymain.c Mymain.h Initial.c Initial.h Menu_Key.c Menu_Key.h
software components: CMSIS:CORE 4.3.0
