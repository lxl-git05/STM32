# Keil uVision project Template_F407ZGT6.uvprojx, settings and files
target Template_F407ZGT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Template_F407ZGT6 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Top;../Mode;../Tools;../Function;../Hardware;../Study
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Top
    ../Top/: Mymain.c Mymain.h AllHeader.c AllHeader.h MyISR.c MyISR.h
  group Mode
    ../Mode/: Mode_G.c Mode_G.h Mode_1.c Mode_1.h Mode_2.c Mode_2.h Mode_3.c Mode_3.h Mode_4.c Mode_4.h Mode_5.c Mode_5.h Mode_6.c Mode_6.h
  group Tools
    ../Tools/: Timer_Counter.c Timer_Counter.h
  group Function
    ../Function/: Serial_porting.c Serial_porting.h
  group Hardware
    ../Hardware/: Serial_base.c Serial_base.h Key.c Key.h OLED.c OLED.h OLED_Data.c OLED_Data.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Study
    ../Study/: MyCAN.c MyCAN.h
software components: CMSIS:CORE 4.3.0
