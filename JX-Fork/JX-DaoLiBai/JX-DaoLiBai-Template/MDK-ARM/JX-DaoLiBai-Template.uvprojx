# Keil uVision project JX-DaoLiBai-Template.uvprojx, settings and files
target JX-DaoLiBai-Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: JX-DaoLiBai-Template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware;../Software;../Tools;../Top;../Mode
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: Key.c OLED.c OLED_Data.c Serial_base.c Serial_porting.c RP.c
  group Top
    ../Top/: AllHeader.c AllHeader.h Mymain.c Mymain.h Timer.c Timer.h
  group Software
    ../Software/: MyPID.c
  group Tools
    ../Tools/: Timer_Counter.c
  group Mode
    ../Mode/: Mode_1.c Mode_1.h Mode_2.c Mode_2.h Mode_3.c Mode_3.h Mode_4.c Mode_4.h Mode_5.c Mode_5.h Mode_6.c Mode_6.h Mode_7.c Mode_7.h Mode_8.c Mode_8.h Mode_9.c Mode_9.h Mode_10.c Mode_10.h Mode_G.c Mode_G.h
software components: CMSIS:CORE 4.3.0
