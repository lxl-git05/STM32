# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Function;../Hardware;../Software;../Tools;../Top;../Mode;../MySystem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group MySystem
    ../MySystem/: MySystem.h MyGPIO.c MyGPIO.h MyPWM.c MyPWM.h MyEncoder.c MyEncoder.h MyTimer.c MyTimer.h
  group Software
    ../Software/: DList.c DList.h Task.c Task.h MyPID.c MyPID.h
  group Hardware
    ../Hardware/: Key.c Key.h OLED.c OLED.h OLED_Data.c OLED_Data.h Serial_base.c Serial_base.h Motor.c Motor.h MPU6050_base.c MPU6050_base.h
  group Function
    ../Function/: Serial.c Serial.h Con_Motor.c Con_Motor.h MPU6050_Angle.c MPU6050_Angle.h Con_Wheel_Control.c Con_Wheel_Control.h
  group Tools
    ../Tools/: Key_Check.c Key_Check.h Timer_Counter.c Timer_Counter.h LED_Flash.c LED_Flash.h Menu_Key.c Menu_Key.h
  group Mode
    ../Mode/: Mode_G.c Mode_G.h Mode_1.c Mode_1.h Mode_2.c Mode_2.h Mode_3.c Mode_3.h Mode_4.c Mode_4.h Mode_5.c Mode_5.h Mode_6.c Mode_6.h
  group Top
    ../Top/: Mymain.c Mymain.h AllHeader.c AllHeader.h
software components: CMSIS:CORE 6.1.1
